# Keil uVision project INCUS_AUDIO_PJ.uvprojx, settings and files
target INUCS_AUDIO_PJ (ARM-ADS)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) IRAM(0x20000000,0x40000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: INCUS_AUDIO_PJ
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,ARM_MATH_CM7, __FPU_PRESENT=1, __FPU_USED =1U, __CC_ARM
  c include: ..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\USER;..\MALLOC;..\APP;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\BUTTON;..\HARDWARE\IIC;..\HARDWARE\LED;..\HARDWARE\NFC;..\HARDWARE\SAI;..\HARDWARE\WM8978;..\APP;..\FLITERLIB;..\MALLOC;..\..\..\..\Drivers\CMSIS\Include;..\HARDWARE\FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group STARTUP
    ../STARTUP/: startup_stm32f723xx.s
  group HALLIB
    ../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c
  group APP
    ../APP/: recorder.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/BUTTON/: button.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SAI/: sai.c
    ../HARDWARE/WM8978/: wm8978.c
    ../HARDWARE/NFC/: nfc.c
    ../HARDWARE/FLASH/: env.c env.h libg.h
  group USER
    ../USER/: system_stm32f7xx.c main.c stm32f7xx_it.c fir2.c audioDataTransProcess.c
  group FILTERLIB
    ../FLITERLIB/: arm_fir_f32.c arm_fir_init_f32.c
    ../../../../Drivers/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
    ../../../../Drivers/CMSIS/DSP_Lib/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
    ../../../../Drivers/CMSIS/DSP_Lib/Source/SupportFunctions/: arm_copy_f32.c
    ../../../../Drivers/CMSIS/Lib/ARM/: arm_cortexM7l_math.lib
software components: CMSIS:CORE 5.1.1
